Commit message: Edited car color, and start location of the car

File: racecar_description/urdf/racecar.xacro (robot description, xacro)
@@ -7,5 +7,5 @@
     <visual>
       <xacro:chassis_geometry/>
-      <material name="blue" />
+      <material name="red" />
     </visual>
   </link>
